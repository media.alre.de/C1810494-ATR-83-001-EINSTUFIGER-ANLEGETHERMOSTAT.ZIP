Properties of the parts of a building model (IFC2X3)

# File
Description: Anlegetemperaturregler, 0-60 °C, Außeneinstellung, IP20, ViewDefinition[CoordinationView]
File name: ifc-2x3.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: C1810494, Anlegetemperaturregler, 0-60 °C, Außeneinstellung, IP20
In: Raum
Description: Anlegethermostat zur Regelung oder Überwachung von Temperaturen an Heizregistern, Rohrleitungen oder Behältern, z. B. temperaturabhängige Pumpensteuerung oder Ansteuerung von Motorventilen.; Classification: EC011173 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: C1810494; ModelLabel: ATR 83.001; GlobalTradeItemNumber: 4050528018984; ProductURL: https://alre.de/produkt_C1810494
Pset_Specification - NominalLength: 0.11 m; NominalWidth: 0.068 m; NominalDepth: 0.052 m; NetWeight: 0.192
Pset_ALRE_ETIM_Properties - Breite: 52; Höhe: 110; Tiefe: 68; Messbereich: 0; Explosionsgeschützt: no; Schutzart (IP): IP20; Ausführung Aufnehmer/Fühler: kapillar; Max. Mediumtemperatur (Dauerbetrieb): 80; Max. Spannung der Kontakte: 230; Kontaktverriegelung: no; Max. Kontaktbelastung: 16; Differenzwert: 4; Differenz verstellbar: no; ETIM-Klasse: EC011173; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-C1810494.pdf
